# Keil uVision project seekfree.uvproj, settings and files
target stc32g144k246 (MCS-251)
  device: AI8052U-32Bit Series AI
  cpu: IRAM(0-0x3FFF) XRAM(0x10000-0x2FFFF) IROM(0xFC0000-0xFFFFFF) CLOCK(35000000)
  output: SEEKFREE +hex
  asm include: ..\..\libraries\zf_common
  link misc: REMOVEUNUSED,NOOVERLAY
  group doc
    ../../libraries/doc/: version.txt
  group zf_common
    ../../libraries/zf_common/: stc32g144k246.h START251.A51 zf_common_headfile.h zf_common_typedef.c zf_common_typedef.h zf_common_clock.c zf_common_clock.h zf_common_interrupt.c zf_common_interrupt.h zf_common_debug.c zf_common_debug.h zf_common_fifo.c zf_common_fifo.h zf_common_font.c zf_common_font.h zf_common_function.c zf_common_function.h
  group zf_driver
    ../../libraries/zf_driver/: zf_driver_adc.c zf_driver_adc.h zf_driver_delay.c zf_driver_delay.h zf_driver_eeprom.c zf_driver_eeprom.h zf_driver_encoder.c zf_driver_encoder.h zf_driver_exti.c zf_driver_exti.h zf_driver_gpio.c zf_driver_gpio.h zf_driver_pit.c zf_driver_pit.h zf_driver_pwm.c zf_driver_pwm.h zf_driver_soft_iic.c zf_driver_soft_iic.h zf_driver_spi.c zf_driver_spi.h zf_driver_timer.c zf_driver_timer.h zf_driver_uart.c zf_driver_uart.h zf_driver_usb_cdc.c zf_driver_usb_cdc.h
  group zf_device
    ../../libraries/zf_device/: zf_device_type.c zf_device_type.h zf_device_config.LIB zf_device_config.h zf_device_mt9v03x.c zf_device_mt9v03x.h zf_device_mt9v03x_dma.LIB zf_device_mt9v03x_dma.h zf_device_ips114.c zf_device_ips114.h zf_device_tft180.c zf_device_tft180.h zf_device_ips200.c zf_device_ips200.h zf_device_ips200pro.c zf_device_ips200pro.h zf_device_ble6a20.c zf_device_ble6a20.h zf_device_wifi_spi.c zf_device_wifi_spi.h zf_device_wireless_uart.c zf_device_wireless_uart.h zf_device_dl1a.c zf_device_dl1a.h zf_device_dl1b.c zf_device_dl1b.h zf_device_imu660ra.c zf_device_imu660ra.h zf_device_imu660rb.c zf_device_imu660rb.h zf_device_imu963ra.c zf_device_imu963ra.h
  group zf_components
    ../../libraries/zf_components/stc32g_usb_lib/: config.h stc.h usb.c usb.h usb_desc.c usb_desc.h usb_req_class.c usb_req_class.h usb_req_std.c usb_req_std.h usb_req_vendor.c usb_req_vendor.h util.c util.h
    ../../libraries/zf_components/seekfree_assistant/: seekfree_assistant.c seekfree_assistant.h seekfree_assistant_interface.c seekfree_assistant_interface.h
  group code
    ../code/: search_line.c user_function.c search_line.h user_function.h
  group user
    ../user/: isr.c isr.h main.c
  group Base
    ../Base/: base.c base.h beep.c beep.h encoder.c encoder.h imu660.c imu660.h motor.c motor.h type_def.h mpu6050.c mpu6050.h tof.c tof.h
    ../code/: global.h
  group camera_process
    ../camera_process/: Element_recognition.c scan_line.c Binarization.c Element_recognition.h scan_line.h Binarization.h circle.c circle.h patch_line.c patch_line.h act_persp.c act_persp.h black_obstacle.c black_obstacle.h zebra.c zebra.h cross.c cross.h
  group GUI
    ../GUI/: application.c application.h display.c GUI.c param_display.c port.c display.h GUI.h param_display.h port.h
  group control
    ../control/: err_calculation.c err_calculation.h filter.c filter.h fuzzy_pid.c fuzzy_pid.h integral.c integral.h mycar.c mycar.h pid.c pid.h ADRC.c ADRC.h
  group interrupt_function
    ../interrupt_function/: timer1_pwm.c timer3_key.c timer4_device.c USART_receive.c timer.h
